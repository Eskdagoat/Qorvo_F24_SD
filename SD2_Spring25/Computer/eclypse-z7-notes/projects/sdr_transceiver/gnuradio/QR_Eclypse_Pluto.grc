options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: fm
    output_language: python
    title: Qorvo Radio Eclypse and Pluto Front End
  states: {}

blocks:
- name: addr
  id: variable
  parameters:
    value: '"192.168.1.100"'
  states: {}
- name: rx_baseband
  id: variable_qtgui_range
  parameters:
    label: Frequency (MHz)
    start: '1000000'
    step: '1000'
    stop: '60000000'
    value: '47000000'
  states: {}
- name: rx_freq
  id: variable_qtgui_range
  parameters:
    label: Frequency (Hz)
    rangeType: int
    start: '80000000'
    step: '100000'
    stop: '2400000000'
    value: '103700000'
  states: {}
- name: rx_samp_rate
  id: variable
  parameters:
    value: '768000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: rx_samp_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: eclypse_z7_qr_rffe_0
  id: eclypse_z7_qr_rffe
  parameters:
    addr: addr
    corr: '0'
    freq: rx_freq
    port: '1000'
  states: {}
- name: eclypse_z7_source_0
  id: eclypse_z7_source
  parameters:
    addr: addr
    corr: '0'
    freq: rx_baseband
    port: '1002'
    rate: rx_samp_rate
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: '47000000'
    samplerate: '768000'
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: rx_freq
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: '768000'
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '90000'
    decim: '1'
    gain: '1'
    samp_rate: rx_samp_rate
    type: fir_filter_ccf
    width: '10000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: rx_samp_rate
    fc: rx_freq*1000000
    fftsize: '1024'
    name: ''
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '16'
    interp: '1'
    taps: ''
    type: fff
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [eclypse_z7_source_0, '0', low_pass_filter_0, '0']
- [eclypse_z7_source_0, '0', qtgui_sink_x_0, '0']
- [iio_pluto_source_0, '0', iio_pluto_sink_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
