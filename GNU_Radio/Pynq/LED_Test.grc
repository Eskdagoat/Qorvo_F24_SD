options:
  parameters:
    author: ambsc
    generate_options: qt_gui
    id: LED_Test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: mixer_chooser1
  id: variable_qtgui_chooser
  parameters:
    label: Mixer Status
    label0: Low End
    label1: High End
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: raw
    value: '0'
    widget: radio_buttons
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0_0
  id: blocks_null_source
  parameters:
    type: int
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import socket
      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[int],
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

                  
          def work(self, input_items, output_items):
              if  self.example_param == 1:
                  client_socket = socket.socket(socket.AF_INET, socket.SOCK_STREAM)
                  client_socket.connect(('192.168.49.58', 1005))
                  client_socket.sendall(b'LED ON')
                  response = client_socket.recv(1024)
                  print(f"Received response: {response.decode('utf-8')}")
                  client_socket.close()
              else:
                  client_socket = socket.socket(socket.AF_INET, socket.SOCK_STREAM)
                  client_socket.connect(('192.168.49.58', 1005))
                  client_socket.sendall(b'LED OFF')
                  response = client_socket.recv(1024)
                  print(f"Received response: {response.decode('utf-8')}")
                  client_socket.close()        
              return len(input_items)
    example_param: mixer_chooser1
  states: {}

connections:
- [blocks_null_source_0, '0', blocks_throttle2_0, '0']
- [blocks_null_source_0_0, '0', epy_block_1, '0']
- [blocks_throttle2_0, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
