options:
  parameters:
    author: Andrew Bowman
    copyright: UNC Charlotte/Qorvo
    generate_options: qt_gui
    id: Pluto_FM
    output_language: python
    title: QORVO_RADIO
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Frequency
    rangeType: int
    start: '90000000'
    step: '50000'
    stop: '107000000'
    value: '103700000'
  states: {}
- name: mixer_chooser1
  id: variable_qtgui_chooser
  parameters:
    label: Low/High Status
    label0: Low End
    label1: High End
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '8'
    quad_rate: '384000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_null_source_0_0
  id: blocks_null_source
  parameters:
    type: int
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import socket
      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[int],
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

                  
          def work(self, input_items, output_items):
              if  self.example_param == 1:
                  client_socket = socket.socket(socket.AF_INET, socket.SOCK_STREAM)
                  client_socket.connect(('192.168.49.58', 1005))
                  client_socket.sendall(b'LED ON')
                  response = client_socket.recv(1024)
                  print(f"Received response: {response.decode('utf-8')}")
                  client_socket.close()
              else:
                  client_socket = socket.socket(socket.AF_INET, socket.SOCK_STREAM)
                  client_socket.connect(('192.168.49.58', 1005))
                  client_socket.sendall(b'LED OFF')
                  response = client_socket.recv(1024)
                  print(f"Received response: {response.decode('utf-8')}")
                  client_socket.close()        
              return len(input_items)
    example_param: mixer_chooser1
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '250000'
    bbdc: 'True'
    buffer_size: '0x20000'
    filter_source: '''Auto'''
    frequency: freq
    gain1: '''manual'''
    manual_gain1: '64'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: '2800000'
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 44.1e3
    decim: '7'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 44.1e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '32768'
    name: Waterfall
    type: complex
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [blocks_null_source_0_0, '0', epy_block_1, '0']
- [iio_pluto_source_0, '0', low_pass_filter_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [iio_pluto_source_0, '0', qtgui_time_sink_x_0, '0']
- [iio_pluto_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
