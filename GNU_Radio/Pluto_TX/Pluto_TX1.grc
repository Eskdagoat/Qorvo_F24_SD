options:
  parameters:
    author: ambsc
    generate_options: qt_gui
    id: Pluto_TX1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: B:\OneDrive\OneDrive\Music\MP3\11 - Wagon Wheel.mp3
    repeat: 'True'
    type: complex
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: '100000000'
    samplerate: '61440000'
    type: fc32
    uri: 192.168.2.10
  states: {}

connections:
- [blocks_file_source_0, '0', iio_pluto_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
